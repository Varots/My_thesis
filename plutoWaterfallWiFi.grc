options:
  parameters:
    generate_options: qt_gui
    id: plutoLoRa
    output_language: python
    title: Testing LoRa device with PlutoSDR
  states: {}

blocks:
- name: B_analog
  id: variable
  parameters:
    comment: |-
      BW of analog filter
      200k to 20 MHz
    value: '50000000'
  states: {}
- name: B_shown
  id: variable
  parameters:
    value: 40e6
  states: {}
- name: fc
  id: variable
  parameters:
    value: '2560000000'
  states: {}
- name: gain_rx
  id: variable
  parameters:
    comment: max of 71 dB, or 62 dB when over 4 GHz center freq
    value: '62'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '41440000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: jammed_channel
    type: complex
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '40000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: fc
    samplerate: samp_rate
    type: fc32
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: B_analog
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: fc
    gain1: '''manual'''
    manual_gain1: gain_rx
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: B_shown
    fc: fc
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: B_shown
    fc: fc
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [iio_pluto_source_0, '0', blocks_file_sink_0, '0']
- [iio_pluto_source_0, '0', iio_pluto_sink_0, '0']
- [iio_pluto_source_0, '0', qtgui_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
